# Keil uVision project DPWC.uvprojx, settings and files
target DPWC (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: DPWC +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\USER;.\USER\Drivers;.\USER\Config;.\USER\Protocol
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group main
    ./USER/: main.c main.h
  group Drivers
    ./USER/Drivers/: Moter.c Moter.h LED.c LED.h Joystick.c Joystick.h Handler.c Handler.h Delay.c Delay.h keys.c keys.h BT04-A.c BT04-A.h TTL_USB.c TTL_USB.h USART.c USART.h Device_PWR.c Device_PWR.h
  group Config
    ./USER/Config/: NVIC.c NVIC.h TIM.c TIM.h
  group Protocol
    ./USER/Protocol/: Protocol.c Protocol.h
software components: CMSIS:CORE 5.0.1, Device:GPIO 1.3, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:PWR 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
